Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-14T16:00:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 14 16:00:48 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{158B6E48-EC6B-42F4-ABDD-229B0BEBE1B4}\ifc * Database version: 5507 * Database creation date: Tue Jun 14 16:00:48 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 14 16:00:48 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 14 16:00:48 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: E4001 LED2N040S, Dummy:E4001 LED2N040S:211900
In: Level 1
Type - PredefinedType: DIRECTIONSOURCE; Material: BERSnl_glas lamp, BE Armatuur
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: Standaard; WT_H Bevestiging: BE_E Armatuur - pendel_E4: Geen; WT_H Breedte: 60 mm; WT_H Halve breedte negatief: -30 mm; WT_H Halve lengte negatief: -1000 mm; WT_H Hoogte: 135 mm; WT_H Individueel: no; WT_H Lengte: 2000 mm; WT_H Lichtbron_breedte: 54 mm; WT_H Lichtbron_lengte: 1800 mm; WT_H Opbouw: yes; WT_H Pendel_breedte: 60 mm; WT_H Pendel_lengte: 1920 mm; WT_H Pendel horizontale armatuurmontage: no; WT_H Referentie: Opbouw; WT_H Symbool wand hoogte: 160 mm; WT_H Symbool wand lengte: 2000 mm; WT_H Uitsteek: -2 mm
Type - Dimensions - BE_G Breedte: 60 mm; BE_G Hoogte: 135 mm; BE_G Lengte: 2000 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 0 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Graphics - WT_V Symbool plafond: TL-armatuur met 1 lamp; WT_V Symbool wand: Geen
Type - Identity Data - BE_I Bestelcode: E4001/LED2N040S; Manufacturer: ETAP; Model: U2; RS_C_drs_content_creator: © Witas; RS_C_drs_content_provider: Etap; RS_C_fabrikant_artikelcode: E4001/LED2N040S; RS_C_fabrikant_bibliotheek_versie: 1; RS_C_fabrikant_jaartal: 2015; RS_C_IFC_versie: 2x3; RS_C_revit_versie: 2012; Type Comments: verlichtingsarmatuur; Type Name: E4001 LED2N040S; URL: http://www.etaplighting.com/level2.aspx?seq=86&seqpicture=2227&name=Lighting&LangType=1033; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - BE_G Materiaal/Kleur: BE Armatuur; WT_V Reflector_materiaal: BERSnl_glas lamp
Type - Model Properties - WT_I Armatuurrendement: 9; WT_I IP: IP40; WT_I Kleur: RAL9016; WT_I Lichtverdeling: diepstralend; WT_I Maatschets catalogus: 354; WT_I Montage: opbouw; WT_I Optiek: lens; WT_I Type: in lijn; WT_I UGR: <=22; WT_I Vorm: langwerpig
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP E4 - lichtbron: E4001_LED2N040_S; WT_I Aantal lampen: 0; WT_I Lamptype: Low PowerLed; WT_I LEDs_aantal: 1; WT_I Lichtstroom armatuur: 4109 lm; WT_I Vermogen lamp: 0 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: E4001 LED2N040S
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Offset lichtbron: 110 mm
Construction - WT_V Koppelstuk_links: yes; WT_V Lijneindstuk_links: no; WT_V Lijneindstuk_rechts: no; WT_V Pendelhoogte: 200 mm
Dimensions - Area: 1.19477 m2; Volume: 0.0486004 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 99
Other - Family: Dummy: E4001 LED2N040S; Family and Type: Dummy: E4001 LED2N040S; Schedule Level: Level: Level 1; Type: Dummy: E4001 LED2N040S; Type Id: Dummy: E4001 LED2N040S
Phasing - Phase Created: 469492
Text - WT_I Revit handleiding: www.witas.be/nl/etap
